/*
 * Генератор чистой противофазы на ATtiny13 для замера мультиметром (без музыки)
 * Питание: 5.0 В
 *
 * Выходы:
 *   PB0 (ножка 5 DIP-8) -> первый щуп мультиметра (+)
 *   PB1 (ножка 6 DIP-8) -> второй щуп мультиметра (-)
 *
 * Опционально (для переключения фазы без перетыкания щупов):
 *   PB2 (ножка 7 DIP-8) -> кнопка или перемычка на GND (с внутренней подтяжкой)
 *   Если кнопку не ставить, скетч сам переключает фазу каждые 2 секунды.
 */

#include <avr/io.h>
#include <util/delay.h>

// Настройка частоты 1.2 МГц (дефолтный делитель /8 от 9.6 МГц)
// Для _delay_ms() компилятору нужен F_CPU, если не задан в настройках ядра
#ifndef F_CPU
#define F_CPU 1200000UL
#endif

static uint8_t phase = 0; // 0: PB0 = HIGH, PB1 = LOW; 1: PB0 = LOW, PB1 = HIGH

static void applyPhase(uint8_t p) {
  if (p == 0) {
    // PB0 = 1 (5.0 В), PB1 = 0 (0 В) -> между PB0 и PB1 будет +5.0 В
    PORTB = (PORTB & ~((1 << PB0) | (1 << PB1))) | (1 << PB0);
  } else {
    // PB0 = 0 (0 В), PB1 = 1 (5.0 В) -> между PB0 и PB1 будет -5.0 В
    PORTB = (PORTB & ~((1 << PB0) | (1 << PB1))) | (1 << PB1);
  }
}

int main(void) {
  // PB0 и PB1 на выход, PB2 на вход с подтяжкой к VCC (для опциональной кнопки)
  DDRB |= (1 << PB0) | (1 << PB1);
  DDRB &= ~(1 << PB2);
  PORTB |= (1 << PB2);

  applyPhase(phase);

  while (1) {
    // Авто-переключение каждые 2 секунды, чтобы мультиметр успел устаканиться
    // При этом можно также нажать кнопку на PB2 на GND для мгновенного переключения
    for (uint8_t i = 0; i < 20; i++) {
      if (!(PINB & (1 << PB2))) {
        // Антидребезг и ожидание отпускания кнопки
        _delay_ms(30);
        while (!(PINB & (1 << PB2))) {
          _delay_ms(10);
        }
        _delay_ms(30);
        phase ^= 1;
        applyPhase(phase);
        i = 0;
      }
      _delay_ms(100);
    }

    phase ^= 1;
    applyPhase(phase);
  }
}
